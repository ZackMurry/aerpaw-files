options:
  parameters:
    author: oozdemi
    generate_options: no_gui
    id: sounder_RX
    output_language: python
    title: Sounder RX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '20'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: AERPAW_Source_0
  id: AERPAW_Source
  parameters:
    args: '""'
    center_freq: 3.5e9
    rx_gain: '40'
    samp_rate: samp_rate
    source: zmq
    zmq_rx_address: tcp://localhost:5001
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: N
    type: complex
    vlen: 4095*M
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 4095*M
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '10000'
    type: complex
    vlen: 4095*M
  states: {}

connections:
- [AERPAW_Source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_one_in_n_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
