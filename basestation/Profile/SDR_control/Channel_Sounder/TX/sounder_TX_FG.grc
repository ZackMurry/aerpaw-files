options:
  parameters:
    author: oozdemi
    generate_options: no_gui
    id: sounder_TX
    output_language: python
    title: Sounder TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: AERPAW_Sink_0_0
  id: AERPAW_Sink
  parameters:
    center_freq: 3.5e9
    samp_rate: samp_rate
    source: zmq
    tx_gain: '60'
    zmq_address: tcp://127.0.0.1:5001
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.99'
    type: complex
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '12'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', AERPAW_Sink_0_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
