options:
  parameters:
    author: kvasude2
    generate_options: no_gui
    id: rcv_udp_tst
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: RX_mode_sel
  id: variable
  parameters:
    value: '[[0], [0], [1]]'
  states: {}
- name: TAP_bytes
  id: variable
  parameters:
    value: '50'
  states: {}
- name: TX_mode_sel
  id: variable
  parameters:
    value: '[[0, 0, 1]]'
  states: {}
- name: UDP_mtu
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: port_offset
  id: variable
  parameters:
    value: node_id
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: tap_mtu
  id: variable
  parameters:
    value: int(UDP_mtu/50)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_2
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: rcv_packet_len
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: '"rcv_packet_len"'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: '"172.18.0."+str(3-node_id)'
    mtu: UDP_mtu
    port: '""+str(20203-node_id)'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: UDP_mtu
    port: '""+str(20200+node_id)'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_1
  id: blocks_socket_pdu
  parameters:
    host: '"172.18.0.100"'
    mtu: UDP_mtu
    port: '""+str(20100+node_id)'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: rcv_packet_len
    type: byte
  states: {}
- name: blocks_tuntap_pdu_0
  id: blocks_tuntap_pdu
  parameters:
    ifn: tap000
    istunflag: 'False'
    mtu: tap_mtu
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: BPSK Modulation
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: node_id
  id: parameter
  parameters:
    short_id: n
    type: intx
    value: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: This changes if the containers talk directly or through the docker bridge (UCHEM)
  states: {}
- name: note_1
  id: note
  parameters:
    note: UDP_mtu controls tap_mtu to prevent UDP bad length from appearing, there is an inflation factor of 50ish and this prevents packets from being broken up inside GNURadio
  states: {}
- name: note_2
  id: note
  parameters:
    note: node_id is a cmd line parameter (-n) which is used to identify which node is being run (-n 1) is the default
  states: {}
- name: note_3
  id: note
  parameters:
    note: These can also be changed to other ip addrs for other emulators
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_1, '0']
- [blocks_pdu_to_tagged_stream_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_pdu_to_tagged_stream_1, pdus]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0_2, print_pdu]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_tuntap_pdu_0, pdus]
- [blocks_tuntap_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tuntap_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_2, '0']

metadata:
  file_format: 1
