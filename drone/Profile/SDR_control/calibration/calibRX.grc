options:
  parameters:
    generate_options: no_gui
    id: calibRX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '100'
    value: '100'
  states: {state: disabled}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '90'
    value: '30'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {state: disabled}
- name: N
  id: parameter
  parameters:
    type: intx
    value: '100'
  states: {}
- name: args
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: N
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: N
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: N
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: N
    max_iter: '4000'
    scale: 1/N
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: N
    max_iter: '4000'
    scale: 1/N
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: N
    max_iter: '4000'
    scale: 1/N
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: file
  id: parameter
  parameters:
    type: str
    value: /root/Power
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 3.5e9
  states: {}
- name: gainrx
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '10'
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-70'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 10e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: args
    gain0: gainrx
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
